# Keil uVision project STM32F4_EthercatARM.uvprojx, settings and files
target STM32F4_EthercatARM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32F4_EthercatARM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,__TARGET_FPU_VFP,ARM_MATH_CM4,__CC_ARM
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\Hardware\global;   ..\Hardware\EtherCAT\Inc;   ..\Hardware\EtherCAT\Hardware;   ..\Hardware\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User
    ../Src/: main.c gpio.c i2c.c iwdg.c spi.c tim.c usart.c usb_otg.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
  group Ethercat/src
    ../Hardware/EtherCAT/src/: aoeappl.c bootmode.c cia402appl.c coeappl.c diag.c ecataoe.c ecatappl.c ecatcoe.c ecateoe.c ecatfoe.c ecatslv.c ecatsoe.c el9800appl.c el9800hw.c emcy.c eoeappl.c foeappl.c mailbox.c objdef.c sdoserv.c
  group Ethecat/hardware
    ../Hardware/EtherCAT/Hardware/: EXIT.c SPI1.c Timer.c
  group Global
    ../Hardware/global/: global.c protocol.c Stepper.c eeprom.c Setting.c Home_limit.c
  group MPU6050
    ../Hardware/MPU6050/: sd_hal_mpu6050.c mpu6050_handle.c
  group DSP
    ../Drivers/CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
software components: CMSIS:CORE 4.3.0
